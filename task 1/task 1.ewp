# IAR project task 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\accio_submissions\lib\STM32 lib\inc_core; D:\accio_submissions\lib\STM32 lib\inc_drivers; D:\accio_submissions\task 1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    ../lib/STM32 lib/src_drivers/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
    ../lib/STM32 lib/copy_to_project/: system_stm32f4xx.c
  group startup
    ../lib/STM32 lib/copy_to_project/: startup_stm32f4xx.s
  group user
    ./: controller.c main.c sd_card.c temperature.c
